# IAR project GIO_LED.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: E:\STM8S003F3\FWLib\include; E:\STM8S003F3\Main; E:\STM8S003F3\User\include; E:\STM8S003F3\UserSTM8\Include
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: GIO_LED.srec
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group FWLib
    FWLib/source/: stm8s_clk.c stm8s_gpio.c
  group MAIN
    Main/: main.c
  group UserSTM8
    UserSTM8/Source/: user_delay.c user_gpio.c
